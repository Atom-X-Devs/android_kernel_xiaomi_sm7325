## drivers/nothing_log/Kconfig
```kconfig
# Nothing logger

config NOTHING_BOOTLOADER_LOG
	tristate "nothing bootloader log"
	default n
	help
		show booloader_log under proc/bootloader_log
```
